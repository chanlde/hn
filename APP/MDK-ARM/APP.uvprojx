# Keil uVision project APP.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: APP +hex
  AfterMake: fromelf --bin -o ".\APP\APP.bin" ".\APP\APP.axf"
  AfterMake: powershell -ExecutionPolicy Bypass -File "..\..\tools\keil_export_named_bin.ps1" -Axf ".\APP\APP.axf" -OutDir ".\APP" -Kind APP -Config "..\..\BSP\dji_sdk_config.h" -FromElf "E:\tool\keil\core\ARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../DJI_PSDK/module_sample;../../DJI_PSDK/psdk_lib/include;../../DJI_PSDK/common/osal;../../DJI_PSDK/BSP;../../DJI_PSDK/USB_HOST/App;../../DJI_PSDK/USB_HOST/Target;../../DJI_PSDK/ST/STM32_USB_Host_Library/Class/CDC/Inc;../../DJI_PSDK/ST/STM32_USB_Host_Library/Core/Inc;../../DJI_PSDK/hal;../../BSP;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\..\DJI_PSDK\APP\common;..\..\DJI_PSDK\APP\air780e_mqtt;..\..\DJI_PSDK\APP\air780e_ppp;..\..\DJI_PSDK\APP\ppp_mqtt;..\..\DJI_PSDK\APP\mqtt_task;..\..\DJI_PSDK\APP\mqtt_cmd_handler;..\..\DJI_PSDK\APP\mqtt_state_publisher;..\..\DJI_PSDK\APP\solarclean_ota;..\..\DJI_PSDK\APP\serial_ota;..\..\DJI_PSDK\APP\ds800_protocol;..\..\DJI_PSDK\module_sample\utils;..\..\DJI_PSDK\module_sample\custom_serial;..\Middlewares\Third_Party\LwIP\port;..\Middlewares\Third_Party\LwIP\src\include
  asm include: ..\Core\Inc;../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\APP\APP.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: cache_utils.c main.c gpio.c freertos.c memorymap.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group PSDK/common
    ../../DJI_PSDK/common/osal/: osal.c
  group PSDK/hal
    ../../DJI_PSDK/hal/: hal_uart.c hal_i2c.c usbd_cdc_vcp.c
  group PSD/lib
    ../../DJI_PSDK/psdk_lib/lib/armcc_cortex-m4/: libpayload.lib
  group PSDK/bsp
    ../../DJI_PSDK/BSP/: uart.c dji_ringbuffer.c led.c pwm.c pwm_swing.c servo_current.c flash_if.c
  group PSDK/air780e
    ../../DJI_PSDK/BSP/: air780e_power.c
    ../../DJI_PSDK/APP/air780e_mqtt/: air780e_mqtt.c
    ../../DJI_PSDK/APP/air780e_ppp/: air780e_ppp.c lwip_port.c
    ../../DJI_PSDK/APP/ppp_mqtt/: ppp_mqtt.c
    ../../DJI_PSDK/APP/mqtt_task/: mqtt_task.c
    ../../DJI_PSDK/APP/mqtt_cmd_handler/: mqtt_cmd_handler.c
    ../../DJI_PSDK/APP/mqtt_state_publisher/: mqtt_state_publisher.c
    ../../DJI_PSDK/APP/solarclean_ota/: solarclean_ota.c solarclean_ota_state.c solarclean_ota_flash.c solarclean_ota_hash.c
    ../../DJI_PSDK/APP/serial_ota/: serial_ota.c
    ../../DJI_PSDK/APP/ds800_protocol/: ds800_protocol.c
  group Middlewares/LwIP/PPP
    ../Middlewares/Third_Party/LwIP/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: icmp.c ip4.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c fsm.c ipcp.c lcp.c magic.c ppp.c pppos.c utils.c
  group BSP
    ../../BSP/: application.c
  group PSDK/samples
    ../../DJI_PSDK/module_sample/widget/: file_binary_array_list_en.c file_binary_array_list_en.h test_widget.c test_widget.h
    ../../DJI_PSDK/module_sample/widget/widget_file_c/en_big_screen/: widget_config_json.h pump_off_png.h pump_on_png.h sway_off_png.h sway_on_png.h pump_power_png.h sway_speed_png.h left_limit_png.h right_limit_png.h
    ../../DJI_PSDK/module_sample/utils/: util_crc.c cJSON.c
    ../../DJI_PSDK/module_sample/custom_serial/: custom_serial.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.1
