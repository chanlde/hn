# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Bootloader +hex
  AfterMake: fromelf --bin -o ".\Bootloader\Bootloader.bin" ".\Bootloader\Bootloader.axf"
  AfterMake: powershell -ExecutionPolicy Bypass -File "..\..\tools\keil_export_named_bin.ps1" -Axf ".\Bootloader\Bootloader.axf" -OutDir ".\Bootloader" -Kind Bootloader -Config "..\..\BSP\dji_sdk_config.h" -FromElf "E:\tool\keil\core\ARM\ARMCC\bin\fromelf.exe"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H743xx
  c include: ..\Core\Inc;..\..\APP\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\APP\Drivers\CMSIS\Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Bootloader.sct
  group Application/MDK-ARM
    ../../APP/MDK-ARM/: startup_stm32h743xx.s
  group Bootloader/Core
    ../Core/Src/: boot_main.c boot_jump.c boot_ota_state.c boot_flash.c boot_sha256.c boot_log.c system_stm32h7xx_boot.c
  group Bootloader/Headers
    ../Core/Inc/: boot_partition.h boot_ota_state.h boot_jump.h boot_flash.h boot_sha256.h boot_log.h
